# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\HARDWARE\M26;..\HARDWARE\LED;..\HARDWARE\WDG;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\EC20
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HardWare
    ../HARDWARE/LED/: led.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/EC20/: EC20.c
  group STMLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_flash.c misc.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group System
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
